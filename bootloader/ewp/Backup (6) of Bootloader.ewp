# IAR project Backup (6) of Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\src; ..\src\CMSIS\Core\CM3; ..\src\StdPeriph_Driver; ..\src\USB-FS-Device_Driver\inc; ..\src\USB-FS-Device_Driver\src; ..\src\hardware
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: ..\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ../../src/target/: target.c
  group CMSIS
    ../src/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group DOCS
    ../../../../Tools/HCC FAT/stm32/fat_372/docs/: fat_372.pdf
    ../../../../../Data sheets/GPS modules/Antenova/: M10372[2].pdf
    ../../../../../Data sheets/GPS modules/: NMEA Reference Manual1.pdf
    ../../../../../Data sheets/Micros/ARM/: stm32f103vd.pdf
  group EWP
    ../src/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
    ../src/target/: target.h
  group FAT
    ../src/fat/: diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c sdio_stm32f1.c sdio_stm32f1.h
  group STD_PERIPH
    ../src/StdPeriph_Driver/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c
  group USER
    ../src/: delay.c eeprom.c FatSD.c firmware_prog.c hardware.c i2c_bitbang.c LCD.c main.c stm32f10x_it.c sysclk.c
