# IAR project Backup (5) of Acoustic Recorder.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; VECT_TAB_FLASH; TEST_MENU_OFF; DEBUG; BOOTLOADER
  ICCARM.CCIncludePath2: ..\src; ..\src\CMSIS\Core\CM3; ..\src\StdPeriph_Driver; ..\src\hardware; ..\src\USB-FS-Device_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Acoustic Recorder.bin
  ILINK.IlinkOutputFile: Acoustic Recorder.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: ..\stm32f10x_flash_with_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; VECT_TAB_FLASH; BOOTLOADER; WATCHDOG
  group CMSIS
    ../src/CMSIS/Core/CM3/: system_stm32f10x.c
  group DOCS
    ../../: versions.txt
  group EWP
    ../src/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group FAT
    ../src/fat/: diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c sdio_stm32f1.c sdio_stm32f1.h
  group STD_PERIPH
    ../src/StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../src/: battery.c crc32.c delay.c dsp_program.c eeprom.c FatSD.c gps.c hardware.c i2c_bitbang.c ini.c LCD.c log.c main.c menu.c nfc.c protocol.c pushbutton.c random.c record.c rtc.c settings.c spi.c stm32f10x_it.c sysclk.c temp_sensor.c test.c
